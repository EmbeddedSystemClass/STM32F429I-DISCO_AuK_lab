# Keil uVision project pierwszy.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pierwszy
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c delay.c ITM_Retarget .c ring_buffer.c ring_buffer_unit_test.c usart.c core.c usart_unit_test.c cli.c trace.c FreeRTOSConfig.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap.c
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:Startup 2.6.2
